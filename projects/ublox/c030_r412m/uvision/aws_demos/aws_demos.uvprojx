# Keil uVision project aws_demos.uvprojx, settings and files
target aws_demos (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F437VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: aws_demos +hex
  AfterMake: fromelf.exe --bin -o $L@L.bin #L
  AfterMake: fromelf.exe -c -o $L@L.dis #L
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_HAL_DRIVER STM32F437xx RTE_Compiler_IO_STDOUT RTE_Compiler_IO_STDOUT_ITM
  c misc: --C99
  c include: ../../../../../freertos_kernel/include;../../../../../freertos_kernel/portable/RVDS/ARM_CM4F;../../../../../demos/include;../../../../../libraries/c_sdk/standard/mqtt/include;../../../../../libraries/c_sdk/standard/common/include;../../../../../libraries/3rdparty/pkcs11;../../../../../libraries/abstractions/secure_sockets/include;../../../../../libraries/c_sdk/standard/common/include/private;../../../../../libraries/freertos_plus/standard/utils/include;../../../../../libraries/abstractions/pkcs11/include;../../../../../libraries/3rdparty/tracealyzer_recorder/Include;../../../../../demos/network_manager;../../../../../libraries/abstractions/platform/include;../../../../../libraries/abstractions/platform/freertos/include;../../../../../libraries/freertos_plus/standard/tls/include;../../../../../libraries/freertos_plus/standard/crypto/include;../../../../../libraries/freertos_plus/standard/pkcs11/include;../../../../../libraries/freertos_plus/standard/crypto/include;../../../../../libraries/abstractions/wifi/include;../../../../../vendors/mediatek/lwip/include;../../../../../demos/dev_mode_key_provisioning/include;../../../../../libraries/c_sdk/aws/defender/include;../../../../../libraries/c_sdk/standard/serializer/include;../../../../../libraries/c_sdk/aws/shadow/include;../../../../../libraries/c_sdk/standard/https/include;../../../../../libraries/freertos_plus/aws/greengrass/include;../../../../../libraries/3rdparty/mbedtls/include;../../../../../libraries/abstractions/pkcs11/mbedtls;../../../../../libraries/3rdparty/mbedtls/include/mbedtls;../../../../../libraries/3rdparty/mbedtls_utils;../../../../../libraries/3rdparty/mbedtls_config;../../../../../libraries/3rdparty/lwip/src/include;../../../../../libraries/3rdparty/lwip_osal/include;../../../../../libraries/3rdparty/tinycbor/src;../../../../../libraries/3rdparty/http_parser;../../../../../libraries/3rdparty/jsmn;../../../../../vendors/ublox/boards/c030_r412m/aws_demos/application_code/st_code;../../../../../vendors/ublox/boards/c030_r412m/aws_demos/application_code;../../../../../vendors/ublox/boards/c030_r412m/aws_demos/config_files;../../../../../vendors/ublox/CMSIS/Include;../../../../../vendors/ublox/STM32F4xx_HAL_Driver/Inc
  asm include: ..\Library\CMSIS\Device\ST\STM32F4xx\Include;..\Library\STM32F4xx_HAL_Driver\Inc;..\Library\CMSIS\Include;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x100000 size 0x10000
  scatter file: ..\..\..\..\..\vendors\mediatek\boards\mt7697hx-dev-kit\aws_demos\flash.sct
  link misc: --entry Reset_Handler --first __isr_vector
  group Startup
    ../../../../../vendors/ublox/boards/c030_r412m/aws_demos/application_code/st_code/: startup_stm32f437xx.s
  group vendors/ublox/STM32F4xx_HAL_Driver
    ../../../../../vendors/ublox/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_exti.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group vendors/ublox/boards/c030_r412m/aws_demos/application_code
    ../../../../../vendors/ublox/boards/c030_r412m/aws_demos/application_code/: main.c
    ../../../../../vendors/ublox/boards/c030_r412m/aws_demos/application_code/st_code/: stm32f4xx_it.c system_stm32f4xx.c retarget_io.c stm32f4xx_hal_timebase_tim.c
  group freertos_kernel/
    ../../../../../freertos_kernel/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos_kernel/include/
    ../../../../../freertos_kernel/include/: FreeRTOS.h StackMacros.h atomic.h croutine.h deprecated_definitions.h event_groups.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h
  group demos/demo_runner/
    ../../../../../demos/demo_runner/: aws_demo_version.c aws_demo.c iot_demo_freertos.c iot_demo_runner.c
  group demos/network_manager/
    ../../../../../demos/network_manager/: aws_iot_network_manager.c aws_iot_demo_network.c iot_network_manager_private.h
  group demos/include/
    ../../../../../demos/include/: aws_application_version.h aws_clientcredential.h aws_clientcredential_keys.h aws_demo.h aws_iot_demo_network.h aws_ota_codesigner_certificate.h iot_config_common.h iot_demo_logging.h iot_demo_runner.h
  group demos/defender/
    ../../../../../demos/defender/: aws_iot_demo_defender.c
  group demos/greengrass_connectivity/
    ../../../../../demos/greengrass_connectivity/: aws_greengrass_discovery_demo.c
  group demos/https/
    ../../../../../demos/https/: iot_demo_https_s3_download_sync.c iot_demo_https_s3_download_async.c iot_demo_https_s3_upload_sync.c iot_demo_https_s3_upload_async.c iot_demo_https_common.c
  group demos/mqtt/
    ../../../../../demos/mqtt/: iot_demo_mqtt.c
  group demos/shadow/
    ../../../../../demos/shadow/: aws_iot_demo_shadow.c
  group demos/tcp/
    ../../../../../demos/tcp/: aws_tcp_echo_client_single_task.c aws_tcp_echo_client_single_tasks.h
  group demos/dev_mode_key_provisioning/src/
    ../../../../../demos/dev_mode_key_provisioning/src/: aws_dev_mode_key_provisioning.c
  group demos/dev_mode_key_provisioning/include/
    ../../../../../demos/dev_mode_key_provisioning/include/: aws_dev_mode_key_provisioning.h
  group libraries/c_sdk/standard/common/
    ../../../../../libraries/c_sdk/standard/common/: iot_init.c iot_static_memory_common.c iot_device_metrics.c
  group libraries/c_sdk/standard/common/include/
    ../../../../../libraries/c_sdk/standard/common/include/: iot_appversion32.h iot_init.h iot_linear_containers.h iot_logging_task.h iot_logging_setup.h iot_taskpool.h
  group libraries/c_sdk/standard/common/logging/
    ../../../../../libraries/c_sdk/standard/common/logging/: iot_logging_task_dynamic_buffers.c iot_logging.c
  group libraries/c_sdk/standard/common/include/private/
    ../../../../../libraries/c_sdk/standard/common/include/private/: iot_logging.h iot_taskpool_internal.h
  group libraries/c_sdk/standard/common/include/types/
    ../../../../../libraries/c_sdk/standard/common/include/types/: iot_network_types.h iot_taskpool_types.h
  group libraries/c_sdk/standard/common/taskpool/
    ../../../../../libraries/c_sdk/standard/common/taskpool/: iot_taskpool.c iot_taskpool_static_memory.c
  group libraries/abstractions/platform/include/platform/
    ../../../../../libraries/abstractions/platform/include/platform/: iot_clock.h iot_network.h iot_threads.h iot_metrics.h
  group libraries/abstractions/platform/include/types/
    ../../../../../libraries/abstractions/platform/include/types/: iot_platform_types.h
  group libraries/abstractions/platform/freertos/
    ../../../../../libraries/abstractions/platform/freertos/: iot_clock_freertos.c iot_threads_freertos.c iot_metrics.c iot_network_freertos.c
  group libraries/abstractions/platform/freertos/include/platform/
    ../../../../../libraries/abstractions/platform/freertos/include/platform/: iot_platform_types_freertos.h iot_network_freertos.h
  group libraries/abstractions/secure_sockets/include/
    ../../../../../libraries/abstractions/secure_sockets/include/: iot_secure_sockets.h iot_secure_sockets_config_defaults.h iot_secure_sockets_wrapper_metrics.h
  group libraries/abstractions/secure_sockets/lwip/
    ../../../../../libraries/abstractions/secure_sockets/lwip/: iot_secure_sockets.c
  group libraries/freertos_plus/standard/tls/src/
    ../../../../../libraries/freertos_plus/standard/tls/src/: iot_tls.c
  group libraries/freertos_plus/standard/tls/include/
    ../../../../../libraries/freertos_plus/standard/tls/include/: iot_tls.h
  group libraries/freertos_plus/standard/crypto/src/
    ../../../../../libraries/freertos_plus/standard/crypto/src/: iot_crypto.c
  group libraries/freertos_plus/standard/crypto/include/
    ../../../../../libraries/freertos_plus/standard/crypto/include/: iot_crypto.h
  group libraries/freertos_plus/standard/pkcs11/include/
    ../../../../../libraries/freertos_plus/standard/pkcs11/include/: iot_pkcs11.h
  group libraries/freertos_plus/standard/pkcs11/src/
    ../../../../../libraries/freertos_plus/standard/pkcs11/src/: iot_pkcs11.c
  group libraries/abstractions/pkcs11/mbedtls/
    ../../../../../libraries/abstractions/pkcs11/mbedtls/: iot_pkcs11_mbedtls.c threading_alt.h
  group libraries/freertos_plus/standard/utils/src/
    ../../../../../libraries/freertos_plus/standard/utils/src/: iot_system_init.c iot_pki_utils.c
  group libraries/freertos_plus/standard/utils/include/
    ../../../../../libraries/freertos_plus/standard/utils/include/: iot_system_init.h iot_pki_utils.h
  group libraries/abstractions/wifi/include/
    ../../../../../libraries/abstractions/wifi/include/: iot_wifi.h
  group libraries/c_sdk/aws/defender/src/
    ../../../../../libraries/c_sdk/aws/defender/src/: aws_iot_defender_api.c aws_iot_defender_collector.c aws_iot_defender_mqtt.c aws_iot_defender_v1.c
  group libraries/c_sdk/aws/defender/src/private/
    ../../../../../libraries/c_sdk/aws/defender/src/private/: aws_iot_defender_internal.h
  group libraries/c_sdk/aws/defender/include/
    ../../../../../libraries/c_sdk/aws/defender/include/: aws_iot_defender.h
  group libraries/c_sdk/standard/mqtt/src/
    ../../../../../libraries/c_sdk/standard/mqtt/src/: iot_mqtt_api.c iot_mqtt_network.c iot_mqtt_operation.c iot_mqtt_serialize.c iot_mqtt_static_memory.c iot_mqtt_subscription.c iot_mqtt_validate.c iot_mqtt_agent.c
  group libraries/c_sdk/standard/serializer/src/cbor/
    ../../../../../libraries/c_sdk/standard/serializer/src/cbor/: iot_serializer_tinycbor_decoder.c iot_serializer_tinycbor_encoder.c
  group libraries/c_sdk/standard/serializer/src/json/
    ../../../../../libraries/c_sdk/standard/serializer/src/json/: iot_serializer_json_decoder.c iot_serializer_json_encoder.c
  group libraries/c_sdk/standard/serializer/src/
    ../../../../../libraries/c_sdk/standard/serializer/src/: iot_serializer_static_memory.c iot_json_utils.c
  group libraries/c_sdk/standard/serializer/include/
    ../../../../../libraries/c_sdk/standard/serializer/include/: iot_serializer.h iot_json_utils.h
  group libraries/c_sdk/aws/shadow/src/
    ../../../../../libraries/c_sdk/aws/shadow/src/: aws_iot_shadow_api.c aws_iot_shadow_operation.c aws_iot_shadow_parser.c aws_iot_shadow_static_memory.c aws_iot_shadow_subscription.c aws_shadow.c aws_shadow_config_defaults.h
  group libraries/c_sdk/aws/shadow/include/
    ../../../../../libraries/c_sdk/aws/shadow/include/: aws_iot_shadow.h aws_shadow.h
  group libraries/c_sdk/standard/https/src/
    ../../../../../libraries/c_sdk/standard/https/src/: iot_https_client.c iot_https_utils.c
  group libraries/freertos_plus/aws/greengrass/src/
    ../../../../../libraries/freertos_plus/aws/greengrass/src/: aws_greengrass_discovery.c aws_helper_secure_connect.c aws_helper_secure_connect.h
  group libraries/freertos_plus/aws/greengrass/include/
    ../../../../../libraries/freertos_plus/aws/greengrass/include/: aws_ggd_config_defaults.h aws_greengrass_discovery.h
  group libraries/3rdparty/mbedtls/library/
    ../../../../../libraries/3rdparty/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group libraries/3rdparty/mbedtls/include/mbedtls/
    ../../../../../libraries/3rdparty/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group libraries/3rdparty/mbedtls_utils/
    ../../../../../libraries/3rdparty/mbedtls_utils/: mbedtls_utils.c mbedtls_error.h mbedtls_error.c
  group libraries/3rdparty/pkcs11/
    ../../../../../libraries/3rdparty/pkcs11/: pkcs11.h pkcs11f.h pkcs11t.h
  group libraries/3rdparty/tinycbor/src/
    ../../../../../libraries/3rdparty/tinycbor/src/: cborpretty.c cborpretty_stdio.c cborencoder.c cborencoder_close_container_checked.c cborerrorstrings.c cborparser.c cborparser_dup_string.c
  group libraries/3rdparty/http_parser/
    ../../../../../libraries/3rdparty/http_parser/: http_parser.h http_parser.c
  group libraries/3rdparty/jsmn/
    ../../../../../libraries/3rdparty/jsmn/: jsmn.h jsmn.c

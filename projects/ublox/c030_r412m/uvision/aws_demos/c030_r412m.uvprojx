# Keil uVision project c030_r412m.uvprojx, settings and files
target c030_r412m (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F437VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: c030_r412m +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER STM32F437xx RTE_Compiler_IO_STDOUT RTE_Compiler_IO_STDOUT_ITM
  c include: ..\Library\CMSIS\Device\ST\STM32F4xx\Include;..\Library\STM32F4xx_HAL_Driver\Inc;..\Library\CMSIS\Include;..\User;..\FreeRTOS-Kernel\include;..\FreeRTOS-Kernel\portable\RVDS\ARM_CM4F
  asm include: ..\Library\CMSIS\Device\ST\STM32F4xx\Include;..\Library\STM32F4xx_HAL_Driver\Inc;..\Library\CMSIS\Include;..\User
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../User/: startup_stm32f437xx.s
  group Library
    ../Library/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_exti.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group User
    ../User/: main.c stm32f4xx_it.c system_stm32f4xx.c retarget_io.c stm32f4xx_hal_timebase_tim.c
  group FreeRTOS
    ../FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS-Kernel/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS-Kernel/portable/MemMang/: heap_3.c
